# Keil uVision project Experiment_3.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ARM7 (Big Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM7TDMI) EBIG
  output: Experiment_3
  c flags: Optim=1
  group Source Group 1
    ./: EXP3C.asm
