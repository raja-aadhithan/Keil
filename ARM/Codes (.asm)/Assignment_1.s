	AREA PROGRAM, CODE, READONLY
	ENTRY
MAIN
		MOVS R0, #0
		MOV R1, #1
		SUBS R2,R0,R1
		BMI LOOP1		;MINUS OPERATION
LOOP2	ADD R7,R7,#1
		SUBS R2,R2,R2
		BEQ LOOP3		;EQUAL OPERATION
LOOP4	ADD R7,R7,#1
		CMP R3,R2 ;R3-R2
		BHI LOOP5		;HIGHER OPERATION
LOOP6	MOV R2,#5
		ADD R7,R7,#1
		ADDS R2,R2,#0xFFFFFFFF
		BCS LOOP7		;CARRY SET
LOOP8	ADD R7,R7,#1
		ADDS R2,R2,#0x0FFFFFFF
		BVC LOOP9		;OVERFLOW CLEAR
LOOP10	ADD R7,R7,#1
		MOV R3,#1
		MOV R2,#5
		CMP R2,R3
		BGT LOOP11		;GREATER THAN
LOOP12	ADD R7,R7,#1
		MOV R3,#1
		MOV R2,#5
		CMP R3,R2
		BLT LOOP13		;LESSER THAN
		BAL LOOP15
LOOP14	ADD R7,R7,#1
		LDR R5,=0x76396869	
		BAL LOOP15		;ALWAYS
LOOP1	ADD R7,R7,#1
		ADDS R2,R2,#5
		BPL LOOP2		;PLUS OPERATION
LOOP3	ADD R7,R7,#1
		ADDS R3,R2,#1
		BNE LOOP4		;NOT EQUAL OPERATION
LOOP5	ADD R7,R7,#1
		CMN R3,R2 
		BLS LOOP6		;LOWER THAN OPERATION
LOOP7	ADD R7,R7,#1
		ADDS R2,R2,#0xFF
		BCC LOOP8		;CARRY CLEAR
LOOP9	ADD R7,R7,#1
		LDR R2,=0x7FFFFFFF
		ADDS R2,R2,#1
		BVS LOOP10		;OVERFLOW SET
LOOP11	ADD R7,R7,#1
		MOV R3,R2
		CMP R3,R2
		BGE LOOP12		;GREATER THAN OR EQUAL
LOOP13	ADD R7,R7,#1
		MOV R3,R2
		CMP R3,R2
		BLE LOOP14		;GREATER THAN OR EQUAL	
LOOP15	ADD R7,R7,#1
		ADDS R0,R0,R0	;TO END
LOOP32	B LOOP32
		END 