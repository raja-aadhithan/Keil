# Keil uVision project ecxp9.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ARM7 (Big Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM7TDMI) EBIG
  output: ecxp9
  c flags: Optim=1
  group Source Group 1
    ./: assen.asm DESEN.ASM
